options:
  parameters:
    author: JOSE F Y DANIEL T
    generate_options: qt_gui
    id: COMU_1
    output_language: python
    title: MISION_1
  states: {}

blocks:
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: GANANCIA RX [dB]
    start: '0'
    step: '1'
    stop: '30'
    value: '20'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia centro MHz
    start: '50'
    step: '1'
    stop: '2200'
    value: '830'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '12500000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc*1e6
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc*1e6
    fftsize: '8192'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc*1e6
    gain0: GRX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
