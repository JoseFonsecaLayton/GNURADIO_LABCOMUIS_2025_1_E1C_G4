options:
  parameters:
    generate_options: qt_gui
    id: Reto7_JF
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: N_0
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: N_0
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"Cálculo de la potencia promedio en ventanas de N muestras\"\"\"\n\n    def __init__(self, vec_len=1024):\n        gr.sync_block.__init__(\n            self,\n            name='Potencia promedio',                # Nombre del bloque\n            in_sig=[np.complex64],                # Entrada: flujo complejo\n            out_sig=[np.float32]                     # Salida: flujo flotante\n        )\n        self.vec_len = int(vec_len)                  # Longitud de ventana\n        self.buffer = np.array([], dtype=np.complex64)\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        out_index = 0\n\n        # Agregar las nuevas muestras al buffer\n        self.buffer = np.concatenate((self.buffer, in0))\n\n        # Mientras haya suficientes muestras para una ventana\n        while len(self.buffer) >= self.vec_len:\n            ventana = self.buffer[:self.vec_len]\n            self.buffer = self.buffer[self.vec_len:]  # Eliminar las usadas\n\n            # Calcular potencia promedio: |x|^2 promedio\n            potencia = np.mean(np.abs(ventana) ** 2)\n            out0[out_index] = np.float32(potencia)\n            out_index += 1\n\n            # Detener si llenamos la salida\n            if out_index >= len(out0):\n                break\n\n        return out_index\n\n"
    alias: Potencia_Promedio
    vec_len: '1024'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"\n    Bloque que calcula la media y desviación estándar de la magnitud\n    sobre una ventana de tamaño vlen, iterando sobre una secuencia compleja continua.\n    \"\"\"\n    def __init__(self, vlen=1024):\n        gr.sync_block.__init__(\n            self,\n            name='Estadísticas de Amplitud (stream)',\n            in_sig=[np.complex64],            # entrada continua (no vector)\n            out_sig=[np.float32, np.float32]  # salidas escalares\n        )\n        self.vlen = int(vlen)\n        self.buffer = np.array([], dtype=np.complex64)\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out_mean = output_items[0]\n        out_std  = output_items[1]\n\n        # Agregamos las nuevas muestras al buffer\n        self.buffer = np.concatenate((self.buffer, in0))\n\n        n_out = 0\n        # Mientras tengamos suficientes muestras para una ventana\n        while len(self.buffer) >= self.vlen:\n            # Tomamos una ventana\n            window = self.buffer[:self.vlen]\n\n            # Calculamos magnitudes\n            mags = np.abs(window)\n\n            # Calculamos estadísticos\n            mean_val = np.mean(mags)\n            std_val  = np.std(mags)\n\n            # Guardamos los resultados en las salidas\n            out_mean[n_out] = mean_val\n            out_std[n_out]  = std_val\n            n_out += 1\n\n            # Desplazamos la ventana (no solapada)\n            self.buffer = self.buffer[self.vlen:]\n\n        return n_out\n\n"
    alias: Estadisticas
    vlen: '1024'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '100'
    grid: 'True'
    nconnections: '3'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Potencia
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Media
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Desv Estandar
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_histogram_sink_x_0, '1']
- [blocks_complex_to_mag_0, '0', qtgui_histogram_sink_x_0, '2']
- [blocks_throttle2_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', epy_block_1, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_1, '0', qtgui_number_sink_1, '0']
- [epy_block_1, '1', qtgui_number_sink_2, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
